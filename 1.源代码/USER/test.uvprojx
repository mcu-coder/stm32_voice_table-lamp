# Keil uVision project test.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\OBJ;..\STM32F1x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F1x_FWLib\src;..\USER;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\HC_SR04;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\TB6612;..\HARDWARE\OLED;..\HARDWARE\kalman;..\HARDWARE\USART2;..\HARDWARE\To_Lx;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\hongwai;..\HARDWARE\USART2;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWILIB
    ../STM32F1x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/HC_SR04/: HC_SR04.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/hongwai/: hongwai.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
